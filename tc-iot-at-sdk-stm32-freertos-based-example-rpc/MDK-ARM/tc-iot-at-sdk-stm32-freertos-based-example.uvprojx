# Keil uVision project tc-iot-at-sdk-stm32-freertos-based-example.uvprojx, settings and files
target tc-iot-at-sdk-stm32-freertos-based-example (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Tc-Iot-STM32F103-Dev-Kit +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/platform;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/device/include;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/mqtt/include;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/sdk-impl;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/utils/digest;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/utils/farra;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/utils/lite;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/sdk-impl/exports;../Middlewares/Third_Party/qcloud-iot-sdk-embedded-c/src/platform/os/freertos/include;../Src/se_uart_inf/HEDSE_HAL;../Src/se_uart_inf/HEDSE_COMM/AlgrithomComm;../Src/se_uart_inf/HEDSE_COMM/AuthComm;../Src/se_uart_inf/HEDSE_COMM/ChallengeComm;../Src/se_uart_inf/HEDSE_COMM/FileComm;../Src/se_uart_inf/HEDSE_COMM/KeyComm;../Src/se_uart_inf/HEDSE_COMM/PinComm;../Src/se_uart_inf/HEDSE_COMM/BaseComm;../Src/se_uart_inf/HEDSE_COMM/TestMain;../Src/se_uart_inf/HEDSE_COMM/IDComm;../Middlewares/Third_Party/qcloud-iot-sdk-tencent-at-based/include;../Middlewares/Third_Party/qcloud-iot-sdk-tencent-at-based/src/include
  asm include: ..\\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c freertos.c stm32f1xx_hal_timebase_TIM.c retarget.c board.c peripheral_drv.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c event_groups.c list.c croutine.c queue.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_pwr.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim.c stm32f1xx_hal_i2c.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group qcloud-iot-sdk-tencent-at-based
    ../Middlewares/Third_Party/qcloud-iot-sdk-tencent-at-based/port/: hal_os.c hal_at.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-tencent-at-based/src/utils/: json_parser.c json_token.c utils_timer.c utils_list.c string_utils.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-tencent-at-based/src/module_at/: at_client.c at_log.c at_utils.c module_api_inf.c ringbuff.c at_timer.c iot_device.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-tencent-at-based/src/mqtt/: mqtt.c
    ../Middlewares/Third_Party/qcloud-iot-sdk-tencent-at-based/src/data_template/: data_template_client.c data_template_client_common.c data_template_client_manager.c data_template_event.c data_template_client_json.c data_template_aciton.c
  group mqtt_sample
    ../Middlewares/Third_Party/qcloud-iot-sdk-tencent-at-based/sample/: mqtt_sample.c
  group data_template_sample
    ../Middlewares/Third_Party/qcloud-iot-sdk-tencent-at-based/usr_logic/: data_template_usr_logic.c
  group light_data_template_sample
    ../Middlewares/Third_Party/qcloud-iot-sdk-tencent-at-based/sample/: light_data_template_sample.c
software components: CMSIS:CORE 4.3.0
